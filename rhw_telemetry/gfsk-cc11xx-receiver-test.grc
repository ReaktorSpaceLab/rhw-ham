<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfsk_cc11xx_receiver_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>int(samp_rate/symbols_per_second)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(2*pi*deviation_hz/8.0)</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>../rhw_telemetry_samples/rhw_fsk_eps_beacon_from_orbit_96k.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cc11xx_cc11xx_deframer_bb</key>
<param><key>id</key><value>cc11xx_cc11xx_deframer_bb_0</value></param>
<param><key>has_ax25_crc</key><value>False</value></param>
<param><key>has_crc</key><value>True</value></param>
<param><key>preamble_bytes</key><value>4</value></param>
<param><key>sync1</key><value>0x35</value></param>
<param><key>sync2</key><value>0x2e</value></param>
<param><key>has_whitening</key><value>True</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>cd_to_module_dir</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import os
os.chdir(os.path.dirname(os.path.abspath(__file__)))
</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_recovery_gain_mu</value></param>
<param><key>value</key><value>0.07</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_recovery_gain_omega</value></param>
<param><key>value</key><value>0.25*0.175*0.175</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_recovery_mu</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_recovery_omega_relative_limit</value></param>
<param><key>value</key><value>0.014</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation_hz</value></param>
<param><key>value</key><value>6000</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>clock_recovery_gain_mu</value></param>
<param><key>gain_omega</key><value>clock_recovery_gain_omega</value></param>
<param><key>mu</key><value>clock_recovery_mu</value></param>
<param><key>omega_relative_limit</key><value>clock_recovery_omega_relative_limit</value></param>
<param><key>omega</key><value>samples_per_symbol</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>10101010</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>preamble</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 7000, 100)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbols_per_second</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc11xx_cc11xx_deframer_bb_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>cc11xx_cc11xx_deframer_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
